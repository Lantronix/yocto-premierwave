require expat.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=7b3b078238d0901d3b339289117cb7fb"

SRC_URI[md5sum] = "686e9d986f85966c7924dfc041cdc15e"
SRC_URI[sha256sum] = "6b902ab103843592be5e99504f846ec109c1abb692e85347587f237a4ffa1033"
