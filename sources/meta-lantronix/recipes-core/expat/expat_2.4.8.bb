require expat.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=9e2ce3b3c4c0f2670883a23bbd7c37a9"

SRC_URI[md5sum] = "ce5fa3fa4d866d83ab0cfb00bb95b77a"
SRC_URI[sha256sum] = "398f6d95bf808d3108e27547b372cb4ac8dc2298a3c4251eb7aa3d4c6d4bb3e2"
