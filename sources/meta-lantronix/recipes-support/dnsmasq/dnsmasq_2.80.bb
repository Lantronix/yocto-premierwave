require dnsmasq.inc

SRC_URI[dnsmasq-2.79.md5sum] = "e040e72e6f377a784493c36f9e788502"
SRC_URI[dnsmasq-2.79.sha256sum] = "cdaba2785e92665cf090646cba6f94812760b9d7d8c8d0cfb07ac819377a63bb"


