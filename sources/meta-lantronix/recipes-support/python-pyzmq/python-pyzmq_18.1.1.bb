require python-pyzmq.inc
inherit setuptools

SRC_URI[md5sum] = "d850bbab7c7f558b91c95b19028ff4b8"
SRC_URI[sha256sum] = "8c69a6cbfa94da29a34f6b16193e7c15f5d3220cb772d6d17425ff3faa063a6d"

