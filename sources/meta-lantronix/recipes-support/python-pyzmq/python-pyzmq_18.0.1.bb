require python-pyzmq.inc
inherit setuptools

SRC_URI[md5sum] = "5a6ed2085bc5e96aa5513fc5cd4a819f"
SRC_URI[sha256sum] = "8b319805f6f7c907b101c864c3ca6cefc9db8ce0791356f180b1b644c7347e4c"

