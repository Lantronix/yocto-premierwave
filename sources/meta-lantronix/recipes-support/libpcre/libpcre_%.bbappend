EXTRA_OECONF_remove = "--enable-utf8"

EXTRA_OECONF += " \
                 --enable-pcre8 \
                 --enable-utf \
                 --enable-unicode-properties \
                "
